# IAR project Thermostat_SK_S7G2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FS7G27H Renesas R7FS7G27H
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: src; src/synergy_gen; synergy/ssp/inc; synergy/ssp/inc/bsp; synergy/ssp/inc/bsp/cmsis/Include; synergy/ssp/inc/driver/api; synergy/ssp/inc/driver/instances; synergy/ssp/inc/framework/api; synergy/ssp/inc/framework/el; synergy/ssp/inc/framework/instances; synergy/ssp/inc/framework/tes; synergy/ssp/src/framework/el/tx; synergy_cfg/ssp_cfg/bsp; synergy_cfg/ssp_cfg/driver; synergy_cfg/ssp_cfg/framework; synergy_cfg/ssp_cfg/framework/el; synergy_cfg/ssp_cfg/framework/tes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Thermost_SK_S7G2_V120.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group Synergy/Source Files/src
    src/: audio.c audio.h audio_playback_thread_entry.c audio_sample.c display_api.h hal_entry.c system_api.h system_cfg.h system_thread_entry.c system_time.c system_time.h temperature_api.h temperature_thread_entry.c time_api.h volume_api.h
  group Synergy/Source Files/src/guix_gen
    src/guix_gen/: hmi_event_handler.c thermostat_resources.c thermostat_resources.h thermostat_specifications.c thermostat_specifications.h
  group Synergy/Source Files/src/guix_gen/lcd_setup
    src/guix_gen/lcd_setup/: lcd.h lcd_setup.c
  group Synergy/Source Files/src/synergy_gen
    src/synergy_gen/: audio_playback_thread.c audio_playback_thread.h common_data.c common_data.h hal_data.c hal_data.h main.c message_data.c pin_data.c system_thread.c system_thread.h temperature_thread.c temperature_thread.h
  group Synergy/Source Files/synergy/board/s7g2_sk
    synergy/board/s7g2_sk/: bsp.h bsp_ethernet_phy.h bsp_init.c bsp_init.h bsp_leds.c bsp_leds.h bsp_qspi.c bsp_qspi.h
  group Synergy/Source Files/synergy/ssp/inc
    synergy/ssp/inc/: ssp_common_api.h ssp_features.h ssp_version.h
  group Synergy/Source Files/synergy/ssp/inc/bsp
    synergy/ssp/inc/bsp/: bsp_api.h
  group Synergy/Source Files/synergy/ssp/inc/bsp/cmsis/Include
    synergy/ssp/inc/bsp/cmsis/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0plus.h core_cm23.h core_cm4.h mpu_armv7.h tz_context.h
  group Synergy/Source Files/synergy/ssp/inc/driver/api
    synergy/ssp/inc/driver/api/: r_adc_api.h r_cgc_api.h r_display_api.h r_elc_api.h r_external_irq_api.h r_fmi_api.h r_i2c_api.h r_ioport_api.h r_jpeg_decode_api.h r_rtc_api.h r_spi_api.h r_transfer_api.h
  group Synergy/Source Files/synergy/ssp/inc/driver/instances
    synergy/ssp/inc/driver/instances/: r_adc.h r_cgc.h r_elc.h r_fmi.h r_glcd.h r_icu.h r_ioport.h r_jpeg_decode.h r_riic.h r_rtc.h r_sci_spi.h
  group Synergy/Source Files/synergy/ssp/inc/framework/api
    synergy/ssp/inc/framework/api/: sf_el_gx_api.h sf_external_irq_api.h sf_jpeg_decode_api.h sf_message_api.h sf_touch_panel_api.h
  group Synergy/Source Files/synergy/ssp/inc/framework/el
    synergy/ssp/inc/framework/el/: gx_api.h gx_display.h gx_port.h gx_utility.h tx_api.h tx_cmsis.h tx_initialize.h tx_port.h tx_trace.h
  group Synergy/Source Files/synergy/ssp/inc/framework/el/cm4_iar
    synergy/ssp/inc/framework/el/cm4_iar/: tx_port.h
  group Synergy/Source Files/synergy/ssp/inc/framework/instances
    synergy/ssp/inc/framework/instances/: sf_el_gx.h sf_external_irq.h sf_jpeg_decode.h sf_message.h sf_touch_panel_i2c.h
  group Synergy/Source Files/synergy/ssp/inc/framework/tes
    synergy/ssp/inc/framework/tes/: dave_base.h dave_driver.h dave_errorcodes.h dave_math.h dave_types.h
  group Synergy/Source Files/synergy/ssp/src/bsp/cmsis/Device/RENESAS/S7G2/Include
    synergy/ssp/src/bsp/cmsis/Device/RENESAS/S7G2/Include/: S7G2.h system_S7G2.h
  group Synergy/Source Files/synergy/ssp/src/bsp/cmsis/Device/RENESAS/S7G2/Source
    synergy/ssp/src/bsp/cmsis/Device/RENESAS/S7G2/Source/: startup_S7G2.c system_S7G2.c
  group Synergy/Source Files/synergy/ssp/src/bsp/cmsis/DSP_Lib/cm4_iar
    synergy/ssp/src/bsp/cmsis/DSP_Lib/cm4_iar/: libDSP_Lib.a
  group Synergy/Source Files/synergy/ssp/src/bsp/mcu/all
    synergy/ssp/src/bsp/mcu/all/: bsp_clocks.h bsp_common.c bsp_common.h bsp_common_leds.c bsp_common_leds.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_error_checking.h bsp_feature.h bsp_group_irq.h bsp_irq.c bsp_irq.h bsp_locking.c bsp_locking.h bsp_mcu_api.h bsp_register_protection.c bsp_register_protection.h bsp_sbrk.c
  group Synergy/Source Files/synergy/ssp/src/bsp/mcu/s7g2
    synergy/ssp/src/bsp/mcu/s7g2/: bsp_cache.c bsp_cache.h bsp_clocks.c bsp_elc.h bsp_feature.c bsp_fmi_R7FS7G27H3A01CFC.c bsp_group_irq.c bsp_hw_locks.c bsp_mcu_info.h bsp_module_stop.c bsp_rom_registers.c
  group Synergy/Source Files/synergy/ssp/src/driver/r_adc
    synergy/ssp/src/driver/r_adc/: r_adc.c r_adc_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_adc/hw
    synergy/ssp/src/driver/r_adc/hw/: hw_adc_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_cgc
    synergy/ssp/src/driver/r_cgc/: r_cgc.c r_cgc_private.h r_cgc_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_cgc/hw
    synergy/ssp/src/driver/r_cgc/hw/: hw_cgc.c hw_cgc.h hw_cgc_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_elc
    synergy/ssp/src/driver/r_elc/: r_elc.c r_elc_private.h r_elc_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_elc/hw
    synergy/ssp/src/driver/r_elc/hw/: hw_elc_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_elc/hw/common
    synergy/ssp/src/driver/r_elc/hw/common/: hw_elc_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_fmi
    synergy/ssp/src/driver/r_fmi/: r_fmi.c
  group Synergy/Source Files/synergy/ssp/src/driver/r_fmi/hw
    synergy/ssp/src/driver/r_fmi/hw/: hw_fmi_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_fmi/hw/common
    synergy/ssp/src/driver/r_fmi/hw/common/: hw_fmi_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_glcd
    synergy/ssp/src/driver/r_glcd/: r_glcd.c r_glcd_private.h r_glcd_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_glcd/hw/common
    synergy/ssp/src/driver/r_glcd/hw/common/: hw_glcd_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_icu
    synergy/ssp/src/driver/r_icu/: r_icu.c r_icu_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_icu/hw
    synergy/ssp/src/driver/r_icu/hw/: hw_icu_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_icu/hw/common
    synergy/ssp/src/driver/r_icu/hw/common/: hw_icu_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_ioport
    synergy/ssp/src/driver/r_ioport/: r_ioport.c r_ioport_private.h r_ioport_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_ioport/hw
    synergy/ssp/src/driver/r_ioport/hw/: hw_ioport_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_jpeg_common
    synergy/ssp/src/driver/r_jpeg_common/: r_jpeg_common.c r_jpeg_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_jpeg_decode
    synergy/ssp/src/driver/r_jpeg_decode/: r_jpeg_decode.c r_jpeg_decode_private.h r_jpeg_decode_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_jpeg_decode/hw
    synergy/ssp/src/driver/r_jpeg_decode/hw/: hw_jpeg_decode_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_jpeg_decode/hw/common
    synergy/ssp/src/driver/r_jpeg_decode/hw/common/: hw_jpeg_decode_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_riic
    synergy/ssp/src/driver/r_riic/: r_riic.c r_riic_private.h r_riic_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_riic/hw
    synergy/ssp/src/driver/r_riic/hw/: hw_riic_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_riic/hw/common
    synergy/ssp/src/driver/r_riic/hw/common/: hw_riic_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_rtc
    synergy/ssp/src/driver/r_rtc/: r_rtc.c r_rtc_private.h r_rtc_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_rtc/hw
    synergy/ssp/src/driver/r_rtc/hw/: hw_rtc_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_rtc/hw/common
    synergy/ssp/src/driver/r_rtc/hw/common/: hw_rtc_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_sci_spi
    synergy/ssp/src/driver/r_sci_spi/: r_sci_spi.c r_sci_spi_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_sci_spi/hw
    synergy/ssp/src/driver/r_sci_spi/hw/: hw_sci_common.h hw_sci_spi_private.h
  group Synergy/Source Files/synergy/ssp/src/framework/el/gx/cm4_iar
    synergy/ssp/src/framework/el/gx/cm4_iar/: libgx.a
  group Synergy/Source Files/synergy/ssp/src/framework/el/tx/cm4_iar
    synergy/ssp/src/framework/el/tx/cm4_iar/: libtx.a
  group Synergy/Source Files/synergy/ssp/src/framework/sf_el_gx
    synergy/ssp/src/framework/sf_el_gx/: gx_display_driver_synergy_dave2d.c gx_display_driver_synergy_dave2d_8bit_palette.c sf_el_gx.c sf_el_gx_private.h sf_el_gx_private_api.h
  group Synergy/Source Files/synergy/ssp/src/framework/sf_external_irq
    synergy/ssp/src/framework/sf_external_irq/: sf_external_irq.c sf_external_irq_private_api.h
  group Synergy/Source Files/synergy/ssp/src/framework/sf_jpeg_decode
    synergy/ssp/src/framework/sf_jpeg_decode/: sf_jpeg_decode.c sf_jpeg_decode_private.h sf_jpeg_decode_private_api.h
  group Synergy/Source Files/synergy/ssp/src/framework/sf_message
    synergy/ssp/src/framework/sf_message/: sf_message.c sf_message_configurator.launch sf_message_configurator.py sf_message_private_api.h
  group Synergy/Source Files/synergy/ssp/src/framework/sf_tes_2d_drw
    synergy/ssp/src/framework/sf_tes_2d_drw/: sf_tes_2d_drw_base.c sf_tes_2d_drw_base.h sf_tes_2d_drw_irq.c sf_tes_2d_drw_memory.c
  group Synergy/Source Files/synergy/ssp/src/framework/sf_touch_panel_i2c
    synergy/ssp/src/framework/sf_touch_panel_i2c/: sf_touch_panel_i2c.c sf_touch_panel_private_api.h
  group Synergy/Source Files/synergy/ssp/src/framework/tes/dave2d
    synergy/ssp/src/framework/tes/dave2d/: dave_64bitoperation.c dave_base.c dave_base.h dave_blit.c dave_box.c dave_box.h dave_circle.c dave_circle.h dave_context.c dave_context.h dave_curve.c dave_curve.h dave_dlist.c dave_dlist.h dave_driver.c dave_edge.c dave_edge.h dave_errorcodes.c dave_gradient.c dave_gradient.h dave_hardware.c dave_hardware.h dave_intern.h dave_line.c dave_line.h dave_math.c dave_memory.c dave_memory.h dave_pattern.c dave_pattern.h dave_perfcount.c dave_polyline.c dave_polyline.h dave_quad.c dave_quad.h dave_rbuffer.c dave_rbuffer.h dave_registermap.h dave_render.c dave_render.h dave_texture.c dave_texture.h dave_triangle.c dave_triangle.h dave_triarray.h dave_utility.c dave_utility.h dave_viewport.c dave_viewport.h dave_wedge.c dave_wedge.h
  group Synergy/Source Files/synergy/ssp_supplemental/touch_drivers/touch_panel_i2c_sx8654
    synergy/ssp_supplemental/touch_drivers/touch_panel_i2c_sx8654/: touch_panel_i2c_sx8654.c
